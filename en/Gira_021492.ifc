Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-07-14T12:13:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jul 14 12:13:19 2019 * Host: DESKTOP-FL8KFT2 * Database: C:\Users\PEACE\AppData\Local\Temp\{4D5BB68F-D765-4648-A6A9-C4F087E9EAEF}\ifc * Database version: 5507 * Database creation date: Sun Jul 14 12:13:16 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jul 14 12:13:17 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jul 14 12:13:17 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 4-g interm.fr. CAl Gira Event Opaque red, Gira_021492:Cov.fr. 4-g interm.fr. CAl Gira Event Opaque red:206910
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 4-g interm.fr. CAl Gira Event Opaque red
Pset_ManufacturerTypeInformation - Manufacturer: Gira
