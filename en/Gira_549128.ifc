Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-17T12:42:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 17 12:42:23 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{5ED8C481-17C4-4C0B-B65C-B8720165AAE4}\ifc * Database version: 5507 * Database creation date: Wed Jul 17 12:42:22 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 17 12:42:22 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 17 12:42:22 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Gira_549128, Gira_549128:Gira_549128:590149
In: Ebene 1
Type - Material: Anthrazit
Pset_BuildingElementProxyCommon - Reference: Gira_549128
Pset_ManufacturerTypeInformation - Manufacturer: Gira
