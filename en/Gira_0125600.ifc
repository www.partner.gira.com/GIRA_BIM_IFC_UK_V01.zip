Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-26T14:03:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 14:03:36 2019 * Host: Toshiba * Database: C:\Users\Samir\AppData\Local\Temp\{11C2BA30-E2FE-40CB-B8C1-E67440095EDB}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 14:03:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 14:03:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 14:03:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: PB sw. series sw. System 55 stainl.steel, Gira_0125600:PB sw. series sw. System 55 stainl.steel:471996
In: Level 1
Type - Material: White
Pset_BuildingElementProxyCommon - Reference: PB sw. series sw. System 55 stainl.steel
Pset_ManufacturerTypeInformation - Manufacturer: Gira
