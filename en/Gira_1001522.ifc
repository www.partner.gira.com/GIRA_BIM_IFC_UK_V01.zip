Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-17T10:00:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 17 10:00:49 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{B1AF9260-3574-4225-8AA8-F8ED4478AFBB}\ifc * Database version: 5507 * Database creation date: Wed Jul 17 10:00:47 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 17 10:00:47 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 17 10:00:47 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 1.5-g Gira Esprit umber gl.C, Gira_1001522:Cov.fr. 1.5-g Gira Esprit umber gl.C:504156
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 1.5-g Gira Esprit umber gl.C
Pset_ManufacturerTypeInformation - Manufacturer: Gira
