Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-26T13:47:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 13:47:23 2019 * Host: HP-PC * Database: C:\Users\HP\AppData\Local\Temp\{56DCF925-66E2-412D-A6BD-F9455A25FB42}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 13:47:19 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 13:47:20 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 13:47:20 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 3-g interm.fr. AN Gira Event Clear aubergine, Gira_0213758:Cov.fr. 3-g interm.fr. AN Gira Event Clear aubergine:376238
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 3-g interm.fr. AN Gira Event Clear aubergine
Pset_ManufacturerTypeInformation - Manufacturer: Gira
