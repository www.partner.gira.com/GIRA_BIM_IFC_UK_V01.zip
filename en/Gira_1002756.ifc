Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-24T17:06:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 24 17:06:30 2019 * Host: Toshiba * Database: C:\Users\Samir\AppData\Local\Temp\{BD4D1D2B-949E-4B1D-8DA9-A964D2BD714C}\ifc * Database version: 5507 * Database creation date: Mon Jun 24 17:06:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 24 17:06:30 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 24 17:06:30 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 2-g w/o cb interm.fr. C Alu Gira Event Clear aubergine, Gira_1002756:Cov.fr. 2-g w/o cb interm.fr. C Alu Gira Event Clear aubergine:376897
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 2-g w/o cb interm.fr. C Alu Gira Event Clear aubergine
Pset_ManufacturerTypeInformation - Manufacturer: Gira
