Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-07-11T16:03:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 11 16:03:17 2019 * Host: DESKTOP-FL8KFT2 * Database: C:\Users\PEACE\AppData\Local\Temp\{CAD7E44D-68DA-4684-A38E-1228C4B4ECA4}\ifc * Database version: 5507 * Database creation date: Thu Jul 11 16:03:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 11 16:03:15 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 11 16:03:15 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 2-g interm.fr. AN Gira Event Opaque red, Gira_021288:Cov.fr. 2-g interm.fr. AN Gira Event Opaque red:208504
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 2-g interm.fr. AN Gira Event Opaque red
Pset_ManufacturerTypeInformation - Manufacturer: Gira
