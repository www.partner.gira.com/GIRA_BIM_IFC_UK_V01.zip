Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-12-09T10:31:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 09 10:31:50 2020 * Host: B-BIM-NB-4765 * Database: C:\Users\BaartC\AppData\Local\Temp\{F2E227E5-36B1-49AA-A5BC-AF05A9739A25}\ifc * Database version: 5507 * Database creation date: Wed Dec 09 10:31:50 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 09 10:31:50 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 09 10:31:50 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: rocker set 2-g inscr. PB sens.4 TS4 alum., Gira_503217:rocker set 2-g inscr. PB sens.4 TS4 alum.:59454
In: Ebene 1
Type - Material: White
Pset_BuildingElementProxyCommon - Reference: rocker set 2-g inscr. PB sens.4 TS4 alum.
Pset_ManufacturerTypeInformation - Manufacturer: Gira
