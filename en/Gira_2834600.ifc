Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-26T14:44:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 14:44:14 2019 * Host: Toshiba * Database: C:\Users\Samir\AppData\Local\Temp\{E9B4D75E-2093-4E41-A6E9-5F74A6BC15E0}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 14:44:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 14:44:14 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 14:44:14 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Rocker sw. BS 20 AX CB 2-p ctrl.l. System 55 stainl.steel, Gira_2834600:Rocker sw. BS 20 AX CB 2-p ctrl.l. System 55 stainl.steel:508031
In: Level 1
Type - Material: White
Pset_BuildingElementProxyCommon - Reference: Rocker sw. BS 20 AX CB 2-p ctrl.l. System 55 stainl.steel
Pset_ManufacturerTypeInformation - Manufacturer: Gira
