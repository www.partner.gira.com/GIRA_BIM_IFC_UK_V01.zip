Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-17T10:43:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 17 10:43:43 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{72CBDA95-DD86-4A55-88B4-ED5F25F1490C}\ifc * Database version: 5507 * Database creation date: Wed Jul 17 10:43:41 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 17 10:43:42 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 17 10:43:42 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Gira_212900, Gira_212900:Gira_212900:533884
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: Gira_212900
Pset_ManufacturerTypeInformation - Manufacturer: Gira
