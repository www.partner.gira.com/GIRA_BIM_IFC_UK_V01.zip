Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-21T12:00:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jul 21 12:00:30 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{0364FE99-63D9-4137-8819-BA7BD844001F}\ifc * Database version: 5507 * Database creation date: Sun Jul 21 12:00:28 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jul 21 12:00:29 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jul 21 12:00:29 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Gira_018200, Gira_018200:Gira_018200:219448
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: Gira_018200
Pset_ManufacturerTypeInformation - Manufacturer: Gira
