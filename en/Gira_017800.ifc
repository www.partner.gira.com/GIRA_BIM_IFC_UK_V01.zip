Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-21T11:58:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jul 21 11:58:26 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{DB6CE433-E54D-4D45-A908-B2D82E36BB80}\ifc * Database version: 5507 * Database creation date: Sun Jul 21 11:58:25 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jul 21 11:58:25 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jul 21 11:58:25 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Gira_017800, Gira_017800:Gira_017800:216039
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: Gira_017800
Pset_ManufacturerTypeInformation - Manufacturer: Gira
