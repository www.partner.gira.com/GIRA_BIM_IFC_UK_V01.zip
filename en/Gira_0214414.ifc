Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-26T11:59:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 11:59:28 2019 * Host: Toshiba * Database: C:\Users\Samir\AppData\Local\Temp\{9957AF14-4D80-46C9-968B-E23608BC765C}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 11:59:27 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 11:59:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 11:59:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 4-g Gira E3 blue grey/p.white, Gira_0214414:Cov.fr. 4-g Gira E3 blue grey/p.white:409912
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 4-g Gira E3 blue grey/p.white
Pset_ManufacturerTypeInformation - Manufacturer: Gira
