Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-17T12:40:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 17 12:40:15 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{8E9AE745-8E55-4077-AB27-CF95F71EB995}\ifc * Database version: 5507 * Database creation date: Wed Jul 17 12:40:13 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 17 12:40:13 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 17 12:40:13 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Gira_549126, Gira_549126:Gira_549126:585131
In: Ebene 1
Type - Material: Anthrazit
Pset_BuildingElementProxyCommon - Reference: Gira_549126
Pset_ManufacturerTypeInformation - Manufacturer: Gira
