Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2019-07-15T15:02:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 15 15:02:45 2019 * Host: Amar_8560w-02 * Database: C:\Users\8560w\AppData\Local\Temp\{AC1C4FA6-DE0F-43B6-B906-30C770C31371}\ifc * Database version: 5507 * Database creation date: Mon Jul 15 15:02:44 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 15 15:02:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 15 15:02:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 1
LongName: Ebene 1; Elevation: 0 mm

# IfcBuildingElementProxy: Auto.ctrl.sw. Komfort 1.10 m Gira TX_44 (WP FM) c.alum., Gira_066165:Auto.ctrl.sw. Komfort 1.10 m Gira TX_44 (WP FM) c.alum.:562177
In: Ebene 1
Pset_BuildingElementProxyCommon - Reference: Auto.ctrl.sw. Komfort 1.10 m Gira TX_44 (WP FM) c.alum.
Pset_ManufacturerTypeInformation - Manufacturer: Gira
