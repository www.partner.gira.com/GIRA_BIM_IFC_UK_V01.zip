Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-07-12T11:25:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 12 11:25:28 2019 * Host: DESKTOP-FL8KFT2 * Database: C:\Users\PEACE\AppData\Local\Temp\{440C621D-4C07-4E65-B44E-DEFD20E9BAA3}\ifc * Database version: 5507 * Database creation date: Fri Jul 12 11:25:25 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 12 11:25:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 12 11:25:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: Cov.fr. 3-g interm.fr. AN Gira Event Opaque blue, Gira_021389:Cov.fr. 3-g interm.fr. AN Gira Event Opaque blue:218630
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Cov.fr. 3-g interm.fr. AN Gira Event Opaque blue
Pset_ManufacturerTypeInformation - Manufacturer: Gira
